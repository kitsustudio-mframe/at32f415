# Keil uVision project chip_arterytek_at32f415.uvprojx, settings and files
target chip (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: chip_arterytek_at32f415 (library)
  AfterMake: cmd.exe /C copy .keil\Objects\chip_arterytek_at32f415.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415RBT7
  c include: .\..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group root
    ./: package-info.h Processor.cpp Processor.h ProcessorCore.h ProcessorInterrupt.h
  group root/adc
    ./adc/: ADC.cpp ADC.h Channel.h Config.h DataAlign.h Flag.h Interrupt.h OrdinaryTrig.h PreemptChannel.h PreemptTrig.h Register.h SampleTime.h VoltageMonitoring.h
  group root/crm
    ./crm/: AutoStepMode.h ClockOutSelect.h CoreClock.h CRM.cpp CRM.h DividerADC.h DividerAHB.h DividerAPB1.h DividerAPB2.h DividerClockOut.h DividerHICK.h DividerUSB.h Flag.h HickFrequencySCLK.h Interrupt.h MultPLL.h package-info.h PeriphClock.h PeriphClockSleepMode.h PeriphReset.h PostDividerPLL.h ReferenceClockPLL.h Register.h SourceClockCore.h SourceClockERTC.h SourceClockPLL.h SourceClockSCLK.h SourceClockUSB.h
  group root/dma
    ./dma/: Channel.h ChannelRegister.h Config.h Direction.h DMA.cpp DMA.h Flag.h Flexible.h Interrupt.h MemoryDataSize.h MemoryInc.h package-info.h PeripheralDataSize.h PeripheralInc.h PriorityLevel.h Register.h
  group root/exint
    ./exint/: Config.h EXINT.cpp EXINT.h Line.h Mode.h Polarity.h Register.h
  group root/pwc
    ./pwc/: DeepSleepEnter.h Flag.h PvmVoltage.h PWC.cpp PWC.h Register.h Regulator.h SleepEnter.h
  group root/misc
    ./misc/: InterruptService.h LowPowerMode.h MISC.cpp MISC.h package-info.h PriorityGroup.h SystickClockSource.h
  group root/flash
    ./flash/: Flag.h FLASH.cpp FLASH.h Interrupt.h package-info.h Register.h Status.h Timeout.h WaitCycle.h
  group root/flash/usd
    ./flash/usd/: Key.h package-info.h Register.h USD.cpp USD.h
  group root/gpio
    ./gpio/: DriveMode.h GPIO.cpp GPIO.h Mode.h OutputMode.h PinConfig.h Pins.h PinsSource.h PortSource.h PullMode.h Register.h
  group root/gpio/iomux
    ./gpio/iomux/: IOMUX.cpp IOMUX.h PinMap.h Register.h
  group root/usart
    ./usart/: BreakBit.h ClockLast.h ClockPhase.h ClockPolarity.h DataBit.h Flag.h HardwareFlow.h Interrupt.h ParitySelection.h Register.h StopBit.h USART.cpp USART.h WakeupMode.h package-info.h
  group root/tmr
    ./tmr/: BreakDutyConfig.h BreakPolarity.h ClockDivision.h CountMode.h EncoderMode.h EventTrigger.h Flag.h Interrupt.h package-info.h PolarityActive.h PrimarySelect.h Register.h TMR.cpp TMR.h WriteProtectLevel.h
  group root/tmr/channel
    ./tmr/channel/: InputConnected.h package-info.h Select.h
  group root/tmr/dma
    ./tmr/dma/: BaseAddress.h package-info.h Request.h RequestSource.h TransferLength.h
  group root/tmr/external
    ./tmr/external/: Divider.h package-info.h Polarity.h
  group root/tmr/input
    ./tmr/input/: Config.h DirectionMapped.h Divider.h package-info.h Polarity.h
  group root/tmr/output
    ./tmr/output/: Config.h ControlMode.h Force.h package-info.h Polarity.h
  group root/tmr/subordinate
    ./tmr/subordinate/: InputSelect.h ModeSelect.h package-info.h

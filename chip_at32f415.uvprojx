# Keil uVision project chip_at32f415.uvprojx, settings and files
target chip (6180000::V6.18::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: chip_at32f415 (library)
  AfterMake: cmd.exe /C copy .keil\Objects\chip_at32f415.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415RBT7
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: chip_arm.h chip_irqn.h AT32F415.cpp AT32F415.h
  group src/adc
    ./adc/: ADC.cpp ADC.h Channel.h Config.h DataAlign.h Flag.h Interrupt.h OrdinaryTrig.h PreemptChannel.h PreemptTrig.h Register.h SampleTime.h VoltageMonitoring.h
  group src/crm
    ./crm/: AutoStepMode.h ClockOutSelect.h CoreClock.h CRM.cpp CRM.h DividerADC.h DividerAHB.h DividerAPB1.h DividerAPB2.h DividerClockOut.h DividerHICK.h DividerUSB.h Flag.h HickFrequencySCLK.h Interrupt.h MultPLL.h package-info.h PeriphClock.h PeriphClockSleepMode.h PeriphReset.h PostDividerPLL.h ReferenceClockPLL.h Register.h SourceClockCore.h SourceClockERTC.h SourceClockPLL.h SourceClockSCLK.h SourceClockUSB.h
  group src/core
    ./core/: Core.cpp Core.h CoreAnalogInputPin.cpp CoreAnalogInputPin.h CoreAnalogInputPort.cpp CoreAnalogInputPort.h CoreGeneralPin.cpp CoreGeneralPin.h CoreGeneralPort.cpp CoreGeneralPort.h CoreHardwareInfo.cpp CoreHardwareInfo.h CoreInterrupt.cpp CoreInterrupt.h CoreIomux.cpp CoreIomux.h InputMode.h OutputMode.h package-info.h CoreUSART.cpp CoreUSART.h CoreTimer.cpp CoreTimer.h CoreEdgeTrigger.cpp CoreEdgeTrigger.h
  group src/dma
    ./dma/: Channel.h ChannelRegister.h Config.h Direction.h DMA.cpp DMA.h Flag.h Flexible.h Interrupt.h MemoryDataSize.h MemoryInc.h package-info.h PeripheralDataSize.h PeripheralInc.h PriorityLevel.h Register.h
  group src/exint
    ./exint/: Config.h EXINT.cpp EXINT.h Line.h Mode.h Polarity.h Register.h
  group src/pwc
    ./pwc/: DeepSleepEnter.h Flag.h PvmVoltage.h PWC.cpp PWC.h Register.h Regulator.h SleepEnter.h
  group src/misc
    ./misc/: InterruptService.h LowPowerMode.h MISC.cpp MISC.h package-info.h PriorityGroup.h SystickClockSource.h
  group src/flash
    ./flash/: Flag.h FLASH.cpp FLASH.h Interrupt.h package-info.h Register.h Status.h Timeout.h WaitCycle.h
  group src/flash/usd
    ./flash/usd/: Key.h package-info.h Register.h USD.cpp USD.h
  group src/gpio
    ./gpio/: DriveMode.h GPIO.cpp GPIO.h Mode.h OutputMode.h PinConfig.h Pins.h PinsSource.h PortSource.h PullMode.h Register.h
  group src/gpio/iomux
    ./gpio/iomux/: IOMUX.cpp IOMUX.h PinMap.h Register.h
  group src/usart
    ./usart/: BreakBit.h ClockLast.h ClockPhase.h ClockPolarity.h DataBit.h Flag.h HardwareFlow.h Interrupt.h ParitySelection.h Register.h StopBit.h USART.cpp USART.h WakeupMode.h package-info.h
  group src/tmr
    ./tmr/: BreakDutyConfig.h BreakPolarity.h ClockDivision.h CountMode.h EncoderMode.h EventTrigger.h Flag.h Interrupt.h package-info.h PolarityActive.h PrimarySelect.h Register.h TMR.cpp TMR.h WriteProtectLevel.h
  group src/tmr/channel
    ./tmr/channel/: InputConnected.h package-info.h Select.h
  group src/tmr/dma
    ./tmr/dma/: BaseAddress.h package-info.h Request.h RequestSource.h TransferLength.h
  group src/tmr/external
    ./tmr/external/: Divider.h package-info.h Polarity.h
  group src/tmr/input
    ./tmr/input/: Config.h DirectionMapped.h Divider.h package-info.h Polarity.h
  group src/tmr/output
    ./tmr/output/: Config.h ControlMode.h Force.h package-info.h Polarity.h
  group src/tmr/subordinate
    ./tmr/subordinate/: InputSelect.h ModeSelect.h package-info.h
  group resource
    ./resource/: chip_interrupt.cpp chip_startup.s
